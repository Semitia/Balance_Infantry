# Keil uVision project balanced_infantry.uvprojx, settings and files
target HUST_balance_infantry (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: balanced_infantry
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx, ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\Algorithm\inc;..\FreeRTOS\include;..\Library\inc;..\Mylib\inc;..\Task\inc;..\User\inc;..\Library\CMSIS;..\User\inc\os;..\User\inc\sys;..\FreeRTOS\port\RVDS\ARM_CM4F;..\Library\SEGGER_RTT_V784\RTT;..\Library\SEGGER_RTT_V784\Config;..\Library\CMSIS\FastMath;..\User\inc\FATFS;..\User\inc\app;..\User\inc\peripheral;..\User\inc\tools;..\User\inc\motor;..\User\inc\config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User/App
    ../User/src/sys/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
    ../User/src/app/: main.c ToggleBullet.c
  group Library
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dbgmcu.c stm32f4xx_spi.c
    ../Library/CMSIS/: arm_cortexM4lf_math.lib
    ../Library/SEGGER_RTT_V784/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Library/CMSIS/FastMath/: arm_atan2_f32.c
  group Mylib
    ../Mylib/src/: os_tick.c can2.c can2_receive.c can1.c can1_receive.c counter.c pc_uart.c can_send.c bluetooth.c wifi.c i2c.c iwdg.c laser.c bsp_servos.c dji_remote.c imu_uart.c
  group Algorithm
    ../Algorithm/src/: QuaternionEKF.c kalman_filter.c algorithmOfCRC.c crc32.c user_lib.c pid.c Observer.c RLS_Identification.c my_filter.c TD.c SystemIdentification.c SignalGenerator.c
  group Task
    ../Task/src/: Start_Task.c CPU_Task.c Test_Task.c Offline_Task.c SDCardTask.c BlueToothTask.c iwdgTask.c GimbalEstimateTask.c ChassisTask.c ActionTask.c GimbalTask.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group SD
    ../Mylib/src/: bsp_spi_sdcard.c
    ../User/inc/FATFS/: ff.c diskio.c
  group User/Motor
    ../User/src/motor/: GM6020.c M2006.c M3508.c
  group User/Tools
    ../User/src/tools/: debug.c tools.c ZeroCheck.c
  group User/Peripheral
    ../User/src/peripheral/: BombBay.c ChassisSolver.c FrictionWheel.c Gimbal.c icm20602.c ins.c pc_serial.c remote_control.c ChassisSend.c ChassisGet.c
